Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_TopControl Modular Maxi Twin_M4-M10_ETCM-M5.4-15.7-Twin_INT-EN.ifc
Time: 2025-08-05T18:23:50+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_TopControl Modular Maxi Twin_M4-M10_INT-EN:ETCM-M5.4-15.7-Twin, M_Pressurization_MEPcontent_Spirotech_SpiroExpand_TopControl Modular Maxi Twin_M4-M10_INT-EN:ETCM-M5.4-15.7-Twin:1911137
In: F00
Type - Material: Color RGB 040-040-040 (2), Color RGB 182-182-182, Color RGB 181-166-066, Color RGB 200-000-000, Color RGB 200-200-200 (2), Color RGB 255-255-255, Color RGB 055-055-055, Color RAL 1003, Color RGB 115-115-115
Type - Other - Category: Mechanical Equipment; Bottom Plate: 654 mm; C: 365.35 mm; D: 1229 mm; E: 551 mm; F: 928 mm; Family Name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_TopControl Modular Maxi Twin_M4-M10_INT-EN; Flange: yes; G: 204 mm; Height to Rectangle: 0 mm; I: 118 mm; J: 114 mm; Middle Plate: 435 mm; Overflow Pipe Length: 692 mm; Overflow Pipe Nominal: 31.75 mm; Overflow Pipe Radius: 24.15 mm; Pipe Angle: 11 deg; Pipe Depth: 93 mm; Pipe Length: 781.6 mm; Pressure Pipe Nominal: 38.1 mm; Pressure Pipe Radius: 24.15 mm; Pump Body 1: 123 mm; Pump Body 2: 51 mm; Pump Height: 398 mm; Rear Pump: no; Rectangle Depth: 104 mm; Rectangle Height: 232 mm; Rectangle Width: 268 mm; S10: no; S4-S10: no; S4-S9: yes; S4-S9 down: yes; Suction Pipe Nominal: 38.1 mm; Suction Pipe Radius: 24.15 mm; Top Part of Pump Height: 234 mm; Unit Depth: 900 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 1075 mm; Height: 1359 mm; Overflow Diameter: 31.75 mm; Pressure Diameter: 38.1 mm; Refill Diameter: 12.7 mm; Suction Diameter: 38.1 mm; Use Nominal Diameter: yes; Width: 1242 mm
Type - Electrical Engineering - Voltage: 400 V
Type - Electrical - Loads - Power: 3200 W
Type - Identity Data - Article Description: TopControl Modular Maxi5.4 - 15.7 bar Twin; Article Type: ETCM-M5.4-15.7-Twin; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: TopControl Modular Maxi5.4 - 15.7 bar Twin; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 23.13; GLN: 8717811000007; GTIN: 8717811050927; Manufacturer: Spirotech; Manufacturer Art. No.: ETCM-M5.4-15.7-Twin; Manufacturer URL: https://www.spirotech.com/8717811050927; MEPcontent Class: VACUUM_DEGASSER; Model: ETCM-M5.4-15.7-Twin; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: ETCM-M5.4-15.7-Twin; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Grey: Color RGB 115-115-115; Grey: Color RGB 200-200-200; Light Black: Color RGB 055-055-055; Red: Color RGB 200-000-000; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Material: Color RGB 040-040-040, Color RGB 182-182-182, Color RGB 181-166-066, Color RGB 200-000-000, Color RGB 200-200-200, Color RGB 255-255-255, Color RGB 055-055-055, Color RAL 1003, Color RGB 115-115-115
Pset_BuildingElementProxyCommon - Reference: ETCM-M5.4-15.7-Twin; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: ETCM-M5.4-15.7-Twin
Other - Angle: 180 deg; Back Clearance Safe: 0 mm; Family: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_TopControl Modular Maxi Twin_M4-M10_INT-EN; Family and Type: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_TopControl Modular Maxi Twin_M4-M10_INT-EN: ETCM-M5.4-15.7-Twin; Front Clearance Safe: 500 mm; Front Pump: yes; Left Clearance Safe: 500 mm; Left Side Pipe: 291.5 mm; Reference Line Length: 62 mm; Refill Angle: 549.5 mm; Right Clearance Safe: 500 mm; Right Side Pipe: 319.5 mm; Top Clearance Safe: 500 mm; Type: ETCM-M5.4-15.7-Twin; Type Id: 1911118
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 17.447 m2; Volume: 0.279614 m3
Identity Data - Mark: 4
Mechanical - Flow In: 0 m3/s; Pressure Flow: 0 m3/s; Refill Flow: 0 m3/s; Suction Flow: 0 m3/s; System Classification: Undefined,Power
Phasing - Phase Created: 3. New Construction
Visibility - Front Clearance: 500 mm; Left Clearance: 500 mm; Left Side Connection: yes; Right Clearance: 500 mm; Right Side Connection: no; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType
OutPort_1911137_1 | SOURCE | PIPE
InPort_1911137_2 | SINK | PIPE
OutPort_1911137_3 | SOURCE | PIPE
InPort_1911137_4 | SINK | PIPE
Port_1911137_5 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
